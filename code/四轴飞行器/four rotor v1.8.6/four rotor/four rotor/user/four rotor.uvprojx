# Keil uVision project four rotor.uvprojx, settings and files
target four rotor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: four rotor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\st_lib\inc;..\st_lib\src;..\driver;..\core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group driver
    ../driver/: systick.c led.c timer.c nvic.c iic.c mpu6050.c gyro_cal.c acc_cal.c mag_cal.c fc_status.c filter.c usart2.c usart3.c spi.c parse_packet.c nrf24l01.c imu.c imath.c ist8310.c spl06.c pwm.c controller.c pid.c adc.c nav.c flash.c sins.c flow.c pair_freq.c
  group st_lib
    ../st_lib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group core
    ../core/: core_cm3.c
  group startup
    ../core/: startup_stm32f10x_md.s
